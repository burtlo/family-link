## client/labs/lab-16-attached-storage/sdkconfig.defaults.server-offline
```kconfig
CONFIG_LAB16_CAPTURE_EVIDENCE=y
CONFIG_LAB16_BUILD_ID="lab16-fw-v5-server-offline-memory"
```
